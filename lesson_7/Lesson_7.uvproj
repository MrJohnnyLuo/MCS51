# Keil uVision project Lesson_7.uvproj, settings and files
target Lesson_7 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Lesson_7 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: LessonNumber = Lesson_7_7
  group Source Group 1
    ./: STARTUP.A51 main.c
